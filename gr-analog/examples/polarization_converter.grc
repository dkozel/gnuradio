options:
  parameters:
    generate_options: qt_gui
    id: testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constant
  id: variable_qtgui_entry
  parameters:
    label: Constant
    type: raw
    value: '1'
  states: {}
- name: num_streams
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_basis_change_0
  id: analog_basis_change
  parameters:
    circ_to_lin: 'True'
    vlen: num_streams
  states: {}
- name: analog_basis_change_1
  id: analog_basis_change
  parameters:
    circ_to_lin: 'False'
    vlen: num_streams
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: constant
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Input
    label2: Input
    label3: Output
    label4: Output
    name: '"Vertical"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Input
    label2: Input
    label3: Output
    label4: Output
    name: '"Horizontal"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Middle"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_basis_change_0, '0', analog_basis_change_1, '0']
- [analog_basis_change_0, '0', qtgui_time_sink_x_0_1, '0']
- [analog_basis_change_0, '1', analog_basis_change_1, '1']
- [analog_basis_change_0, '1', qtgui_time_sink_x_0_1, '1']
- [analog_basis_change_1, '0', qtgui_time_sink_x_0, '1']
- [analog_basis_change_1, '1', blocks_probe_rate_0, '0']
- [analog_basis_change_1, '1', qtgui_time_sink_x_0_0, '1']
- [analog_sig_source_x_0, '0', analog_basis_change_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_basis_change_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
